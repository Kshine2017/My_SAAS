# Keil uVision project Active_Rcord.uvprojx, settings and files
target Active_Rcord (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\led;..\..\User\sdcard;..\..\STM32_USB-FS-Device_Driver\inc;..\..\Mass_Storage\inc;..\..\User\machine_control;..\..\User\err_contol;..\..\User\file;..\..\User\rtc;..\..\User\key;..\..\User\i2c;..\..\User\time;..\..\User\ad;..\..\User\systerm_time;..\..\User\ADXL345;..\..\User\SPI;..\..\User\Flash;..\..\User\Environment;..\..\User\FATFS;..\..\User\FATFS\option;..\..\User\usb
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_USB-FS-Device_Driver
    ../../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Mass_Storage
    ../../Mass_Storage/src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group FATFS
    ../../User/FATFS/: diskio.c ff.c
    ../../User/FATFS/option/: my_cc936.c
  group USART1
    ../../User/usart/: usart1.c
  group MACHINE_CONTROL
    ../../User/machine_control/: machine_control.c
  group RTC
    ../../User/rtc/: rtc.c date.c
  group FILE
    ../../User/file/: file.c
  group ERR_CONTROL
    ../../User/err_contol/: err_control.c
  group KEY
    ../../User/key/: key.c
  group IIC
    ../../User/i2c/: i2c_1.c i2c_2.c
  group TIME
    ../../User/time/: time.c
  group ADC
    ../../User/ad/: ad.c
  group Systerm_Time
    ../../User/systerm_time/: systerm_time.c
  group ADXL345
    ../../User/ADXL345/: ADXL345.c
  group Flash
    ../../User/Flash/: Flash.c
  group SPI
    ../../User/SPI/: SPI.c
  group Environment
    ../../User/Environment/: Environment.c
  group Readme
    ../../Doc/: readme.txt
  group USB
    ../../User/usb/: usb.c
  group BH1750fvi
    ../../User/BH1750fvi/: bh1750fvi.c
